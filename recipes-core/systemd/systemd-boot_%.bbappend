# Built against this board's kernel/device-tree tree (external-dt), so it differs per board.
PACKAGE_ARCH = "${MACHINE_ARCH}"

# Changes feed in this release; see the PR note in conf/layer.conf.
PR = "r1"
