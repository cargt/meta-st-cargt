FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Increase-delays-and-retries-to-avoid-a-panic-if-the-.patch \
            file://0002-add-logs-for-demo-purpose.patch \
            "

