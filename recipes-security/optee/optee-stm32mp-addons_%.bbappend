# Built against this board's kernel/device-tree tree (external-dt), so it differs per board.
PACKAGE_ARCH = "${MACHINE_ARCH}"
