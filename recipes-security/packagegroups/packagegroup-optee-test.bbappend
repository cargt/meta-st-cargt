# Pulls in this board's OP-TEE (device-tree dependent) packages, so it differs per board.
PACKAGE_ARCH = "${MACHINE_ARCH}"
