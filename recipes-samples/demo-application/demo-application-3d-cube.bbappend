# Built against weston-cube, which is board-specific.
PACKAGE_ARCH = "${MACHINE_ARCH}"

# Changes feed in this release; see the PR note in conf/layer.conf.
PR = "r1"
